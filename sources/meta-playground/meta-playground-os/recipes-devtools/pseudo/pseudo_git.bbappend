SRC_URI:remove = "file://0001-configure-Prune-PIE-flags.patch file://older-glibc-symbols.patch"
SRCREV = "823895ba708c63f6ae4dcbfc266210f26c02c698"
PV = "1.9.8+git"
